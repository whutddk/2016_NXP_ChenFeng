<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <group>
      <name>BSP</name>
      <file>
        <name>$PROJ_DIR$\..\..\src\app\ITAC\BSP.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\app\bsp_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\app\iIc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\app\IIC.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\app\LDC1614.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\app\LDC1614.h</name>
      </file>
    </group>
    <group>
      <name>CTL</name>
      <file>
        <name>$PROJ_DIR$\..\..\src\app\ITAC\control.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\app\ITAC\ctl.h</name>
      </file>
    </group>
    <group>
      <name>ITAC</name>
      <file>
        <name>$PROJ_DIR$\..\..\src\app\ITAC\bz_led.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\app\ITAC\freecars.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\app\ITAC\freecars.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\app\ITAC\ITAC.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\app\ITAC\OLED.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\app\ITAC\OLED.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\calculate.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\isr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\main.c</name>
    </file>
  </group>
  <group>
    <name>common</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\alloc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\assert.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\io.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\memtest.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\printf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\startup.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\stdlib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\uif.c</name>
    </file>
  </group>
  <group>
    <name>cpu</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\arm_cm0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\crt0.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\start.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\sysinit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\vectors.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\vectors.h</name>
    </file>
  </group>
  <group>
    <name>drivers</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\adc\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\DMA\dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\gpio\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\i2c\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\lptmr\lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\mcg\mcg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\pit\pit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\port\port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\systick\systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\tpm\tpm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\uart\uart.c</name>
    </file>
  </group>
  <group>
    <name>headers</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\fire_drivers_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\platforms\freedom.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\gpio\gpio_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\include.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\isr.h</name>
    </file>
  </group>
</project>


