# IAR project Backup of Landzo_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Landzo_gpio_demo.hex
  ILINK.IlinkOutputFile: Landzo_demo.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.CoreVariant: 35
  ICCARM.CCDefines: NDEBUG; IAR; MKL25Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: ..\..\src\app; ..\..\src\app\ITAC; ..\..\src\common; ..\..\src\common\io; ..\..\src\common\startup; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\drivers; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\uart; ..\..\src\drivers\port; ..\..\src\drivers\dma; ..\..\src\drivers\pit; ..\..\src\drivers\tpm; ..\..\src\drivers\ADC; ..\..\src\platforms; $TOOLKIT_DIR$\inc
  ICCARM.CCOptLevel: 0
  ILINK.IlinkOutputFile: Landzo_gpio_demo.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../../src/app/: calculate.c isr.c main.c
  group app/BSP
    ../../src/app/: ADC_get.c bsp_init.c flash.c flash.h iIc.c IIC.h key.c LDC1614.c LDC1614.h record.c
    ../../src/app/ITAC/: BSP.h
  group app/CTL
    ../../src/app/: control.c motor.c sensor.c
    ../../src/app/ITAC/: ctl.h
  group app/ITAC
    ../../src/app/ITAC/: bz_led.c freecars.c freecars.h GUI.c GUI.h ITAC.h OLED.c OLED.h
  group common
    ../../src/common/: alloc.c assert.c common.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    ../../src/cpu/: arm_cm0.c crt0.s start.c sysinit.c vectors.c vectors.h
  group drivers
    ../../src/drivers/adc/: adc.c
    ../../src/drivers/DMA/: dma.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/i2c/: i2c.c
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/pit/: pit.c
    ../../src/drivers/port/: port.c
    ../../src/drivers/systick/: systick.c
    ../../src/drivers/tpm/: tpm.c
    ../../src/drivers/uart/: uart.c
  group headers
    ../../src/common/: common.h
    ../../src/drivers/: fire_drivers_cfg.h
    ../../src/platforms/: freedom.h
    ../../src/drivers/gpio/: gpio_cfg.h
    ../../src/app/: include.h isr.h
