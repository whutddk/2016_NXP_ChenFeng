<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\adc\adc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\adc\adc.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\cmp\cmp.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\cmp\cmp.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\dac\dac.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\dac\dac.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\DMA\dma.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\DMA\dma.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\mcg\Fire_kinetis_MCG_CFG.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\gpio\gpio.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\gpio\gpio.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\gpio\gpio_cfg.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\i2c\i2c.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\i2c\i2c.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\i2c\i2c_cfg.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\lptmr\lptmr.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\lptmr\lptmr.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\mcg\mcg.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\mcg\mcg.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\mcg\mcg_cfg.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\pit\pit.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\pit\pit.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\port\port.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\port\port.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\rtc\rtc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\rtc\rtc.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\spi\SPI.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\spi\SPI.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\systick\systick.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\systick\systick.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\tpm\tpm.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\tpm\tpm.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\tsi\tsi.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\tsi\tsi.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\uart\uart.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\landzoKL25_LED&#x8C03;&#x8BD5;&#x7A0B;&#x5e8F;\src\drivers\uart\uart.h</name>
  </file>
</project>


