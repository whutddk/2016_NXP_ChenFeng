# IAR project STATIC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; IAR; MKL25Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: ..\landzoKL25_LED调试程序\src\app; ..\landzoKL25_LED调试程序\src\app; ..\landzoKL25_LED调试程序\src\app\ITAC; ..\landzoKL25_LED调试程序\src\common; ..\landzoKL25_LED调试程序\src\common\io; ..\landzoKL25_LED调试程序\src\common\startup; ..\landzoKL25_LED调试程序\src\cpu; ..\landzoKL25_LED调试程序\src\cpu\headers; ..\landzoKL25_LED调试程序\src\drivers; ..\landzoKL25_LED调试程序\src\drivers\gpio; ..\landzoKL25_LED调试程序\src\drivers\i2c; ..\landzoKL25_LED调试程序\src\drivers\lptmr; ..\landzoKL25_LED调试程序\src\drivers\mcg; ..\landzoKL25_LED调试程序\src\drivers\uart; ..\landzoKL25_LED调试程序\src\drivers\port; ..\landzoKL25_LED调试程序\src\drivers\dma; ..\landzoKL25_LED调试程序\src\drivers\pit; ..\landzoKL25_LED调试程序\src\drivers\tpm; ..\landzoKL25_LED调试程序\src\drivers\ADC; ..\landzoKL25_LED调试程序\src\platforms; $TOOLKIT_DIR$\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: STATIC.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../landzoKL25_LED调试程序/src/drivers/adc/: adc.c adc.h
    ../landzoKL25_LED调试程序/src/drivers/cmp/: cmp.c cmp.h
    ../landzoKL25_LED调试程序/src/drivers/dac/: dac.c dac.h
    ../landzoKL25_LED调试程序/src/drivers/DMA/: dma.c dma.h
    ../landzoKL25_LED调试程序/src/drivers/mcg/: Fire_kinetis_MCG_CFG.h mcg.c mcg.h mcg_cfg.h
    ../landzoKL25_LED调试程序/src/drivers/gpio/: gpio.c gpio.h gpio_cfg.h
    ../landzoKL25_LED调试程序/src/drivers/i2c/: i2c.c i2c.h i2c_cfg.h
    ../landzoKL25_LED调试程序/src/drivers/lptmr/: lptmr.c lptmr.h
    ../landzoKL25_LED调试程序/src/drivers/pit/: pit.c pit.h
    ../landzoKL25_LED调试程序/src/drivers/port/: port.c port.h
    ../landzoKL25_LED调试程序/src/drivers/rtc/: rtc.c rtc.h
    ../landzoKL25_LED调试程序/src/drivers/spi/: SPI.c SPI.h
    ../landzoKL25_LED调试程序/src/drivers/systick/: systick.c systick.h
    ../landzoKL25_LED调试程序/src/drivers/tpm/: tpm.c tpm.h
    ../landzoKL25_LED调试程序/src/drivers/tsi/: tsi.c tsi.h
    ../landzoKL25_LED调试程序/src/drivers/uart/: uart.c uart.h
