<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\NXP_(golden_cyprinoid)_K60.ewp</path>
  </project>
  <batchBuild/>
</workspace>


