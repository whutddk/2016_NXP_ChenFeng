# IAR project fire_camera_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\port; ..\..\src\drivers\delay; ..\..\src\drivers\dma; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\LCD; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\key; ..\..\src\drivers\NRF24L0; ..\..\src\drivers\ov7725; ..\..\src\drivers\spi; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\sdhc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\drivers\camera; ..\..\src\drivers\OLED; ..\..\src\drivers\USB; ..\..\src\drivers\USB_CDC; ..\..\src\drivers\sound; ..\..\src\drivers\MPU6050; ..\..\src\drivers\flash; ..\..\src\projects\fire_camera_demo; ..\..\build
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_gpio_demo.hex
  ILINK.IlinkOutputFile: fire_gpio_demo.out
  ILINK.IlinkIcfFile: ..\config files\fire_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; TWR_K60N512; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\port; ..\..\src\drivers\delay; ..\..\src\drivers\dma; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\LCD; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\key; ..\..\src\drivers\NRF24L0; ..\..\src\drivers\ov7725; ..\..\src\drivers\spi; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\sdhc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\drivers\camera; ..\..\src\drivers\OLED; ..\..\src\drivers\USB; ..\..\src\drivers\USB_CDC; ..\..\src\drivers\sound; ..\..\src\drivers\MPU6050; ..\..\src\drivers\eMPL; ..\..\src\drivers\flash; ..\..\src\projects\fire_camera_demo; ..\..\build
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: fire_camera_demo.bin
  group app
    ../../src/projects/fire_camera_demo/: isr.c main.c
  group common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/Flash/: flash.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/key/: key.c
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/OLED/: OLED.c
    ../../src/drivers/sdhc/: sdhc.c
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/wdog/: wdog.c
  group drivers/FatFs
    ../../src/LIB/FatFs/: diskio.c ff.c
